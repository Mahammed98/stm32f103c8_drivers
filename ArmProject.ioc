# file: ArmProject.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2024 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"
#include "delay.h"
#include "GPIO_interface.h"
#include "RCC_interface.h"
#include "EXTI_interface.h"
#include "Systick_interface.h"
#include "DMA_interface.h"

void SystemClock_Config(void);
//static void MX_GPIO_Init(void);

volatile u32 arr1[500];
volatile u32 arr2[500];

void App_void_ToggleLed(void);
void fun(void);

int main(void)
{
  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  //HAL_Init();
  /* Configure the system clock */
  //SystemClock_Config();
  //M_SysTick_void_Init();
  //M_SysTick_voidSetIntervalPeriodic(500000,fun);
  M_RCC_Void_ClkSourceInit();
  M_RCC_Void_EnableClock(APB2,IOPAEN);
  M_RCC_Void_EnableClock(AHB1,DMA1EN);    // enable DMA
  //MX_GPIO_Init();
  M_GPIO_void_SetPinMode(PORTA_GPIO, 4, OUTPUT_MAX_SPEED_10MHZ, GPO_PUSH_PULL);  // output
  M_GPIO_void_SetPinMode(PORTA_GPIO, 3, OUTPUT_MAX_SPEED_10MHZ, GPO_PUSH_PULL);  // output

  /*  initialize DMA */
  M_DMA_void_Init(1,MEMORY_TO_MEMORY_MODE, READ_FROM_PERIPHERAL, PERIPHERAL_SIZE_32_BIT, MEMORY_SIZE_32_BIT, CHANNEL_PRIORITY_HIGH);
  M_DMA_void_SendData(1, arr1, arr2, 500);
  M_DMA_void_SetCallBack(fun,1);
  /*   enable interrupt for DMA  */
  NVIC_EnableIRQ(DMA1_Channel1_IRQn);
  NVIC_SetPriority(DMA1_Channel1_IRQn,1);
  __enable_irq();   //enable global interrupt

  /*  fill source array */
for (u16 i = 0; i < 499; i++)
{
	arr1[i] = i;
}
	arr1[499] = 1;

	M_DMA_void_EnableDma(1);
	//while(M_DMA_u8_ReadTransferCompleteFlag(1) == 0);

  while(1)
  {
	  //M_GPIO_void_WritePinBSRR(PORTA_GPIO,4,HIGH);
	 // M_SysTick_DelayMs(2000);
	 //M_GPIO_void_WritePinBSRR(PORTA_GPIO,4,LOW);
	  //M_SysTick_DelayMs(2000);
  }
}

void fun(void)
{
	if(M_DMA_u8_ReadTransferCompleteFlag(1))
	{
		M_GPIO_void_WritePinBSRR(PORTA_GPIO,3,arr2[499]);   // indicator for transferring all data reaching to end of arr1
		M_GPIO_void_WritePinBSRR(PORTA_GPIO,4,HIGH);
		M_DMA_void_ClearTransferCompleteFlag(1);  // clear GIF, AND TCF
	}
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL2;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }

  /** Enables the Clock Security System
  */
  HAL_RCC_EnableCSS();
}
/*static void MX_GPIO_Init(void)
{
  GPIO_InitTypeDef GPIO_InitStruct = {0};

  //__HAL_RCC_GPIOC_CLK_ENABLE();
  //__HAL_RCC_GPIOD_CLK_ENABLE();
  //__HAL_RCC_GPIOA_CLK_ENABLE();

  HAL_GPIO_WritePin(GPIOB, GPIO_PIN_4, GPIO_PIN_SET);

  GPIO_InitStruct.Pin = GPIO_PIN_4;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_MEDIUM;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

}*/

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
